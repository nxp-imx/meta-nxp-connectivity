FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-Add-Matter-and-OTBR-configs.patch"
SRC_URI += "file://0002-imx93-otbr-devicetree.patch"
SRC_URI += "file://0001-Enable-otbr-and-firewall-configs-for-imx6-7.patch"
