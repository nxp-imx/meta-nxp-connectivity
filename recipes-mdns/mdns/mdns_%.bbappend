FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-mdnsd-ifa_addr-SEGFAULT-dont-read-sa_family-field.patch"
