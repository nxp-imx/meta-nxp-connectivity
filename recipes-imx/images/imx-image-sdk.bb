DESCRIPTION = "This is for matter-sdk"

inherit core-image

IMAGE_INSTALL += " packagegroup-sdk "

export IMAGE_BASENAME = "imx-image-sdk"
